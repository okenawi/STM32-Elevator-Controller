# Keil uVision project Proj. Elevator-2.0.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Proj. Elevator-2.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group New Group
    ./: Test Keypad.s Code.s LCD_Screen.s Buzzer_Test.s Servo_Door.s Floor_Servos.s NFC_RC522_Test.s dfplayer.s bluetooth.s RFID.s
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
